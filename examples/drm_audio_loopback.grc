options:
  parameters:
    author: HenryDelMal
    category: '[DRM Examples]'
    comment: Experimental DReaM-inspired Opus mode; not part of the ETSI DRM standard.
    description: 'Full experimental DRM transmitter and receiver loopback: Opus, MLC, OFDM, synchronization, channel decoding, and sound-card playback.'
    gen_cmake: 'Off'
    generate_options: qt_gui
    id: drm_audio_loopback
    output_language: python
    title: DRM Full Audio Transceiver Loopback
  states: {}

blocks:
- name: tp
  id: variable_drm_config
  parameters:
    RM: '1'
    SO: '3'
    audio_sample_rate: '24000'
    long_interl: 'False'
    msc_mapping: '1'
    msc_prot_level_2_16: '1'
    msc_prot_level_2_64: '0'
    sdc_mapping: '1'
    station_label: '"gr-drm loopback"'
    text_message: '"Full DRM transmitter and receiver"'
  states: {}
- name: opus_bitrate
  id: variable
  parameters:
    comment: Opus target bitrate in bit/s; zero selects the maximum payload rate.
    value: '12000'
  states: {}
- name: rx_bitrate_status
  id: variable_qtgui_label
  parameters:
    comment: In this loopback the receiver knows the transmitter target; independent receivers require future SDC metadata.
    formatter: 'lambda x: f"{x / 1000:.1f} kbit/s target"'
    gui_hint: 'tx_rx_tabs@1: 1,1,1,1'
    label: Opus bitrate
    type: int
    value: tx_used_bitrate
  states: {}
- name: rx_codec_status
  id: variable_qtgui_label
  parameters:
    gui_hint: 'tx_rx_tabs@1: 1,0,1,1'
    label: Codec
    type: string
    value: '"Opus (experimental)"'
  states: {}
- name: rx_detection_status
  id: variable_qtgui_label
  parameters:
    gui_hint: 'tx_rx_tabs@1: 1,3,1,1'
    label: Detection
    type: string
    value: '"MSC/SDC mapping + interleaver from FAC"'
  states: {}
- name: rx_pcm_status
  id: variable_qtgui_label
  parameters:
    gui_hint: 'tx_rx_tabs@1: 1,2,1,1'
    label: Decoded PCM
    type: string
    value: f"{tp.cfg().audio_samp_rate() / 1000:g} kHz mono float32"
  states: {}
- name: tx_available_bitrate
  id: variable_qtgui_label
  parameters:
    comment: Maximum Opus payload after the per-packet border and CRC overhead.
    formatter: 'lambda x: f"{x / 1000:.1f} kbit/s"'
    gui_hint: 'tx_rx_tabs@0: 2,1,1,1'
    label: Available Opus payload
    type: int
    value: int(((tp.msc().L_MUX() - 400) // 160) * 400)
  states: {}
- name: tx_mode_status
  id: variable_qtgui_label
  parameters:
    gui_hint: 'tx_rx_tabs@0: 2,0,1,1'
    label: DRM waveform
    type: string
    value: f"RM {(\"A\", \"B\", \"C\", \"D\", \"E\")[tp.cfg().RM()]}, SO {tp.cfg().SO()}, MSC {16 if tp.cfg().msc_mapping() == 1 else 64}-QAM, SDC {4 if tp.cfg().sdc_mapping() == 1 else 16}-QAM, {\"long\" if tp.cfg().long_interl() else \"short\"} interleaver"
  states: {}
- name: tx_payload_utilization
  id: variable_qtgui_label
  parameters:
    comment: Configured Opus target as a percentage of the usable Opus payload.
    formatter: 'lambda x: f"{x:.1f} %"'
    gui_hint: 'tx_rx_tabs@0: 2,3,1,1'
    label: Payload utilization
    type: real
    value: 100.0 * tx_used_bitrate / tx_available_bitrate
  states: {}
- name: tx_used_bitrate
  id: variable_qtgui_label
  parameters:
    comment: Effective configured bitrate; Opus bitrate zero means use all available payload.
    formatter: 'lambda x: f"{x / 1000:.1f} kbit/s"'
    gui_hint: 'tx_rx_tabs@0: 2,2,1,1'
    label: Used Opus bitrate
    type: int
    value: tx_available_bitrate if opus_bitrate == 0 else opus_bitrate
  states: {}
- name: audio_encoder
  id: drm_opus_audio_encoder_fb
  parameters:
    application: '"audio"'
    bandwidth: '"auto"'
    bitrate: opus_bitrate
    complexity: '10'
    dtx: 'False'
    signal: '"auto"'
    tp: tp
    vbr: 'False'
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /Users/henry/ecdc/27f_biobio_24k_mono.wav
    repeat: 'True'
  states: {}
- name: carrier_vector_to_stream
  id: blocks_vector_to_stream
  parameters:
    comment: Flatten mapped carriers for the constellation display.
    num_items: tp.ofdm().nfft()
    type: complex
  states: {}
- name: cell_mapper
  id: cell_mapping_cc
  parameters:
    tp: tp
  states: {}
- name: constellation_preview
  id: qtgui_const_sink_x
  parameters:
    comment: MSC, SDC, FAC, and reference carriers before the IFFT.
    grid: 'True'
    gui_hint: 'tx_rx_tabs@0: 0,0,1,1'
    label1: '"DRM carriers"'
    name: '"DRM Transmit Constellation"'
    size: '2048'
    type: complex
  states: {}
- name: cyclic_prefix
  id: digital_ofdm_cyclic_prefixer
  parameters:
    comment: Serialize each IFFT vector and prepend the DRM cyclic prefix.
    cp_len: tp.ofdm().n_cp()
    input_size: tp.ofdm().nfft()
    tagname: '""'
  states: {}
- name: decoded_audio_preview
  id: qtgui_time_sink_x
  parameters:
    comment: Recovered PCM samples selected after FAC-driven MSC decoding.
    entags: 'False'
    grid: 'True'
    gui_hint: 'tx_rx_tabs@1: 0,0,1,1'
    label1: Decoded audio
    name: '"DRM Receiver Decoded Audio"'
    size: '2048'
    srate: tp.cfg().audio_samp_rate()
    type: float
  states: {}
- name: fac_generator
  id: drm_generate_fac_b
  parameters:
    tp: tp
  states: {}
- name: fac_mlc
  id: mlc_bc
  parameters:
    channel_type: '"FAC"'
    tp: tp
  states: {}
- name: fac_scrambler
  id: drm_scrambler_bb
  parameters:
    block_len: tp.fac().L()
  states: {}
- name: ifft
  id: fft_vxx
  parameters:
    comment: Convert mapped DRM carriers to time-domain OFDM symbols.
    fft_size: tp.ofdm().nfft()
    forward: 'False'
    shift: 'True'
    type: complex
    window: '[]'
  states: {}
- name: msc_interleaver
  id: drm_interleaver_cc
  parameters:
    depth: drm.INTL_DEPTH_DRM
    interl_seq: tp.msc().cell_interl_seq()
    long_interl: tp.cfg().long_interl()
  states: {}
- name: msc_mlc
  id: mlc_bc
  parameters:
    channel_type: '"MSC"'
    tp: tp
  states: {}
- name: msc_scrambler
  id: drm_scrambler_bb
  parameters:
    block_len: tp.msc().L_MUX()
  states: {}
- name: programme_tone
  id: analog_sig_source_x
  parameters:
    amp: '0.05'
    comment: Replace this tone with a 24 kHz mono WAV or audio source.
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: '24000'
    type: float
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: rx_auto_receiver
  id: drm_opus_auto_receiver_ccf
  parameters:
    audio_sample_rate: tp.cfg().audio_samp_rate()
    comment: FAC selects MSC/SDC mapping and interleaver depth from received baseband.
    msc_protection: tp.cfg().msc_prot_level_2()
    rm: tp.cfg().RM()
    so: tp.cfg().SO()
  states: {}
- name: sdc_generator
  id: drm_generate_sdc_b
  parameters:
    tp: tp
  states: {}
- name: sdc_mlc
  id: mlc_bc
  parameters:
    channel_type: '"SDC"'
    tp: tp
  states: {}
- name: sdc_scrambler
  id: drm_scrambler_bb
  parameters:
    block_len: tp.sdc().L()
  states: {}
- name: soundcard_sink
  id: audio_sink
  parameters:
    comment: Recovered 24 kHz PCM from the full DRM receiver.
    device_name: '""'
    samp_rate: tp.cfg().audio_samp_rate()
  states: {}
- name: transmitter_spectrum
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: tp.ofdm().fs_soundcard()
    comment: FFT of the serialized DRM OFDM baseband after cyclic-prefix insertion.
    fc: '0'
    fftsize: '2048'
    grid: 'True'
    gui_hint: 'tx_rx_tabs@0: 1,0,1,1'
    label: Relative power
    label1: DRM baseband
    name: '"DRM Transmit Baseband FFT"'
    type: complex
    ymin: '-120'
  states: {}
- name: tx_rx_tabs
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0,2,2
    label0: '"Transmitter"'
    label1: '"Receiver"'
    num_tabs: '2'
  states: {}

connections:
- [audio_encoder, '0', msc_scrambler, '0']
- [blocks_wavfile_source_0, '0', audio_encoder, '0']
- [carrier_vector_to_stream, '0', constellation_preview, '0']
- [cell_mapper, '0', carrier_vector_to_stream, '0']
- [cell_mapper, '0', ifft, '0']
- [fac_generator, '0', fac_scrambler, '0']
- [fac_mlc, '0', cell_mapper, '2']
- [fac_scrambler, '0', fac_mlc, '0']
- [ifft, '0', cyclic_prefix, '0']
- [msc_interleaver, '0', cell_mapper, '0']
- [msc_mlc, '0', msc_interleaver, '0']
- [msc_scrambler, '0', msc_mlc, '0']
- [sdc_generator, '0', sdc_scrambler, '0']
- [sdc_mlc, '0', cell_mapper, '1']
- [sdc_scrambler, '0', sdc_mlc, '0']
- [cyclic_prefix, '0', rx_auto_receiver, '0']
- [cyclic_prefix, '0', transmitter_spectrum, '0']
- [rx_auto_receiver, '0', decoded_audio_preview, '0']
- [rx_auto_receiver, '0', soundcard_sink, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
