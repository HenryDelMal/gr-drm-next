options:
  parameters:
    author: HenryDelMal
    category: '[DRM Examples]'
    comment: 'Perfect MSC loopback: validates FAAC framing and FAAD2 decoding before adding an RF receiver.'
    description: DRM audio encoder to FAAD2 decoder loopback with sound-card playback.
    gen_cmake: 'Off'
    generate_options: qt_gui
    id: drm_audio_loopback
    output_language: python
    title: DRM Audio Encoder/Decoder Loopback
  states: {}

blocks:
- name: tp
  id: variable_drm_config
  parameters:
    RM: '1'
    SO: '3'
    audio_sample_rate: '24000'
    long_interl: 'False'
    msc_mapping: '1'
    msc_prot_level_2_16: '1'
    msc_prot_level_2_64: '0'
    sdc_mapping: '1'
    station_label: '"gr-drm loopback"'
    text_message: '"FAAC to FAAD2 audio loopback"'
  states: {}
- name: programme_tone
  id: analog_sig_source_x
  parameters:
    amp: '0.05'
    comment: Replace this deterministic tone with a 24 kHz mono WAV source if desired.
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: '24000'
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: pcm_scale
  id: blocks_multiply_const_vxx
  parameters:
    comment: FAAC float input scaling used by the transmitter block.
    const: '32768.0'
    type: float
  states: {}
- name: audio_encoder
  id: drm_audio_encoder_sb
  parameters:
    len_out: tp.msc().L_MUX()
    tp: tp
  states: {}
- name: msc_frame
  id: blocks_stream_to_vector
  parameters:
    num_items: tp.msc().L_MUX()
    type: byte
  states: {}
- name: audio_decoder
  id: drm_audio_decoder_sb
  parameters:
    tp: tp
  states: {}
- name: soundcard_sink
  id: audio_sink
  parameters:
    comment: Decoded PCM output. Select the desired macOS output device.
    device_name: '""'
    samp_rate: '24000'
  states: {}

connections:
- [programme_tone, '0', pcm_scale, '0']
- [pcm_scale, '0', audio_encoder, '0']
- [audio_encoder, '0', msc_frame, '0']
- [msc_frame, '0', audio_decoder, '0']
- [audio_decoder, '0', soundcard_sink, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
